# Keil uVision project project.uvproj, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99
  c include: applications;.;board;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\arm926;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\hwcrypto;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\libraries\nuc980\rtt_port;..\..\..\components\fal\inc;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\dfs\filesystems\ramfs;..\..\..\components\dfs\filesystems\romfs;..\..\..\components\finsh;.;..\..\..\include;..\libraries\nuc980\Driver\Include;..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\components\net\lwip\port;packages\netutils-latest\ntp;packages\netutils-latest\tftp;.;..\libraries\nu_packages\Demo;..\libraries\nu_packages\SPINAND;..\libraries\nu_packages\TPC;..\libraries\nuc980\UsbHostLib\inc;..\libraries\nu_packages\NuUtils\inc;packages\optparse-latest;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;packages\ramdisk-latest\inc;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\drivers\usb\usbhost;..\..\..\components\drivers\usb\usbhost\class;..\..\..\components\drivers\usb\usbhost\core;..\..\..\components\drivers\usb\usbhost\include;..\..\..\components\drivers\include;..\..\..\components\net\netdev\include;..\..\..\components\net\sal\include;..\..\..\components\net\sal\include\socket;..\..\..\components\net\sal\impl;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\net\sal\include\socket\sys_socket;soem-1.4.0\osal\rt-thread;soem-1.4.0\oshw\rt-thread;soem-1.4.0\soem;packages\uffs-latest;packages\uffs-latest\src\inc;..\..\..\components\utilities\utest
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\nuc980.sct
  group Applications
    applications/: mnt.c soem_test.c sv660n_test.c main.c net_util.c
  group board
    board/: nu_pin_init.c board_dev.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../../libcpu/arm/arm926/: stack.c mmu.c machine.c context_rvds.S start_rvds.S cpuport.c trap.c
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/hwcrypto/: hw_symmetric.c hwcrypto.c hw_rng.c hw_hash.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: dataqueue.c completion.c waitqueue.c pipe.c ringblk_buf.c workqueue.c ringbuffer.c
    ../../../components/drivers/misc/: adc.c pin.c
    ../../../components/drivers/mtd/: mtd_nand.c
    ../../../components/drivers/rtc/: soft_rtc.c rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    ../libraries/nuc980/rtt_port/: drv_systick.c drv_common.c drv_softi2c.c drv_pwm.c drv_qspi.c drv_rtc.c drv_gpio.c drv_wdt.c drv_etimer.c drv_uart.c drv_crypto.c drv_i2s.c drv_scuart.c drv_spi.c drv_i2c.c drv_etimer_capture.c drv_usbd.c drv_pdma.c drv_sys.c drv_can.c drv_sdh.c drv_ebi.c drv_adc.c drv_usbhost.c drv_emac.c
  group Fal
    ../../../components/fal/src/: fal.c fal_rtt.c fal_partition.c fal_flash.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: ffunicode.c ff.c dfs_elm.c
    ../../../components/dfs/filesystems/ramfs/: dfs_ramfs.c
    ../../../components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../src/: irq.c clock.c components.c memheap.c mem.c thread.c device.c object.c idle.c signal.c ipc.c scheduler.c timer.c mempool.c kservice.c
  group Libraries
    ../libraries/nuc980/Driver/Source/: nu_sys.c nu_pdma.c nu_gpio.c nu_usbd.c nu_emac.c nu_spi.c nu_rtc.c nu_i2s.c nu_crypto.c nu_i2c.c nu_wdt.c nu_scuart.c nu_can.c nu_wwdt.c nu_ebi.c nu_cap.c nu_etimer.c nu_sdh.c nu_uart.c nu_qspi.c
  group lwIP
    ../../../components/net/lwip/lwip-2.1.2/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c if_api.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/: ip.c netif.c sys.c altcp_alloc.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c altcp.c tcp_in.c dns.c timeouts.c udp.c altcp_tcp.c pbuf.c def.c tcp.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    ../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group NetUtils
    packages/netutils-latest/iperf/: iperf.c
    packages/netutils-latest/ntp/: ntp.c
    packages/netutils-latest/tcpdump/: tcpdump.c
    packages/netutils-latest/tftp/: tftp_client.c tftp_server.c tftp_xfer.c tftp_port.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_cdc_vcom_echo.c slcd_show_tick.c usbd_hid_dance_mouse.c
  group nu_pkgs_spinand
    ../libraries/nu_packages/SPINAND/: drv_spinand.c spinand.c
  group nuc980_usbhostlib
    ../libraries/nuc980/UsbHostLib/src/: ohci.c mem_alloc.c usb_core.c support.c ehci_iso.c ehci.c
  group optparse
    packages/optparse-latest/: optparse.c
  group POSIX
    ../../../components/libc/posix/io/poll/: select.c poll.c
  group ramdisk
    packages/ramdisk-latest/src/: drv_ramdisk.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/drivers/usb/usbdevice/class/: cdc_vcom.c
  group rt_usbh
    ../../../components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
    ../../../components/drivers/usb/usbhost/class/: udisk.c mass.c
  group SAL
    ../../../components/net/netdev/src/: netdev_ipaddr.c netdev.c
    ../../../components/net/sal/src/: sal_socket.c
    ../../../components/net/sal/socket/: net_sockets.c net_netdb.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_lwip.c
  group Soem
    soem-1.4.0/osal/rt-thread/: osal.c
    soem-1.4.0/oshw/rt-thread/: netdev_hook.c nicdrv.c oshw.c
    soem-1.4.0/soem/: ethercatbase.c ethercatfoe.c ethercatconfig.c ethercatdc.c ethercatsoe.c ethercatmain.c ethercatcoe.c ethercateoe.c ethercatprint.c
  group uffs
    packages/uffs-latest/src/uffs/: uffs_mem.c uffs_mtb.c uffs_crc.c uffs_tree.c uffs_flash.c uffs_version.c uffs_debug.c uffs_blockinfo.c uffs_public.c uffs_find.c uffs_buf.c uffs_pool.c uffs_device.c uffs_fd.c uffs_utils.c uffs_ecc.c uffs_badblock.c uffs_init.c uffs_fs.c
    packages/uffs-latest/: uffs_nandif.c dfs_uffs.c uffs_rtthread.c
  group UTest
    ../../../components/utilities/utest/: utest.c
